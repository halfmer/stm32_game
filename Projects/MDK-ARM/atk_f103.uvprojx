# Keil uVision project atk_f103.uvprojx, settings and files
target JOYPAD (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\;..\..\User;..\..\Middlewares
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_msp_template.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_sram.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_rtc.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c led.h
    ../../Drivers/BSP/LCD/: lcd.c lcd.h lcdfont.h
    ../../Drivers/BSP/JOYPAD/: joypad.c joypad.h
  group Drivers/BSP/GUI
    ../../Drivers/BSP/GUI/: graph.c graph.h gui.c gui.h model.c model.h draw_base.c draw_base.h data.h Rendering.c Rendering.h
  group Drivers/BSP/RUN
    ../../Drivers/BSP/RUN/: run.c run.h util.c util.h
  group Readme
    ../../: readme.txt
